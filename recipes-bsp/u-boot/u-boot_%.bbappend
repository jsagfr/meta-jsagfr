SRCREV = "a705ebc81b7f91bbd0ef7c634284208342901149"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-beaglebone-green-wireless-support.patch"

